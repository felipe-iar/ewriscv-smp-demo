# IAR project ewriscv-smp-simple-demo.ewp, settings and files
configuration Debug (RISCV, debug)
  General.GDeviceSelect: MicrochipPolarfireU54 Microchip Polarfire U54
  General.GHeapSize: 0x1000
  ICCRISCV.IccLang: 0
  ICCRISCV.CCOptLevel: 1
  ICCRISCV.CCOptStrategy: 0
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: BasicDebugging.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: core0.c core1.c core2.c core3.c cstartup.s main.c
